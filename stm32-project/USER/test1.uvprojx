# Keil uVision project test1.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\KEY;..\HARDWARE\USART2;..\HARDWARE\BLT;..\HARDWARE\BEEP;..\HARDWARE\SMG;..\HARDWARE\CONTROL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group FWILB
    ../FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_rtc.c stm32f10x_sdio.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/BLT/: blt.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/CONTROL/: control.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
